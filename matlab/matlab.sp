* autogenerated spice file, vov = 0.700
.include /usr/class/ee114/hspice/ee114_hspice.sp
vdd     n_vdd   0       2.5
vss     n_vss   0       -2.5
Iin     n_iin   0       ac      1
RL      n_vout  0       20000
CL      n_vout  0       250f
Cin     n_iin   0       220f
MN1     n_iin   n_bias_n  n_vss   n_vss nmos114 w=3.0u l=2.0u
MN2     n_x     0         n_iin  n_vss  nmos114 w=24.0u l=1.0u
MP3     n_x     n_bias_p  n_vdd  n_vdd  pmos114 w=6.0u l=2.0u
MP4     n_w     n_x       n_vdd  n_vdd  pmos114 w=6.0u l=1.0u
MP5     n_y     0         n_w    n_vdd  pmos114 w=6.0u l=1.0u
MN6     n_y     n_bias_n  n_vss  n_vss  nmos114 w=3.0u l=2.0u
MN7     n_z     n_y       n_vss  n_vss  nmos114 w=2.0u l=1.0u
MP8     n_z     n_z       n_vdd  n_vdd  pmos114 w=2.0u l=1.0u
MN9     n_vout  n_bias_n  n_vss  n_vss  nmos114 w=5.0u l=2.0u
MN10    n_vdd   n_z       n_vout n_vss  nmos114 w=28.0u l=1.0u
R1      n_vdd   n_x       19200
R2      n_x     0         20800
R3      n_y     0         168100
R4      n_y     n_vss     34400
MP100   n_bias_n n_bias_p n_vdd n_vdd  pmos114 w=4u  l=2u
MP200   n_bias_p n_bias_p n_vdd n_vdd  pmos114 w=4u  l=2u
MN300   n_bias_n n_bias_n n_vss n_vss  nmos114 w=2u  l=2u
MN400   n_bias_p n_bias_n n_biasr2   n_vss  nmos114 w=4u l=2u
R200    n_biasr2 n_vss  16.7k
MN700   n_biasn9 n_bias_n n_vss n_vss nmos114 w=5u  l=2u
MP800   n_biasn9 n_bias_n n_vdd n_vdd pmos114 w=2u  l=9u
MN900   n_bias_p n_biasn9 n_vss n_vss nmos114 w=4u  l=2u
.op
.option post brief nomod
.ac dec 1k 100 1g
.pz v(n_vout) Iin
.measure ac gainmax_vin max vdb(n_iin)
.measure ac f3db_vin when vdb(n_iin)="gainmax_vin-3"
.measure ac gainmax_vx max vdb(n_x)
.measure ac f3db_vx when vdb(n_x)="gainmax_vx-3"
.measure ac gainmax_vw max vdb(n_w)
.measure ac f3db_vw when vdb(n_w)="gainmax_vw-3"
.measure ac gainmax_vy max vdb(n_y)
.measure ac f3db_vy when vdb(n_y)="gainmax_vy-3"
.measure ac gainmax_vz max vdb(n_z)
.measure ac f3db_vz when vdb(n_z)="gainmax_vz-3"
.measure ac gainmax_vout max vdb(n_vout)
.measure ac f3db_vout when vdb(n_vout)="gainmax_vout-3"
.end
